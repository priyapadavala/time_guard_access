# Keil uVision project time_guard_access.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2138 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: time_guard_access
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s lcd_u.c mini_proj_interrupt.c mini_proj_kpm.c mini_proj_main.c mini_proj_test.c rtc.c mini_proj_declar.h mini_proj_defines.h
    ../: delay.h types.h delay.c
